options:
  parameters:
    author: Phlash
    copyright: Phil Ashby, 2022
    description: AIS reception via SoapyTCP (dual channel)
    generate_options: qt_gui
    id: AIS
    output_language: python
    title: AIS receiver
  states: {}

blocks:
- name: ais_string
  id: variable_qtgui_entry
  parameters:
    label: AIS
    type: string
    value: '--'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain (dB)
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: xlate_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 15000, 5000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: zmq_address
  id: variable
  parameters:
    value: '"tcp://127.0.0.1:7533"'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '.3'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '.3'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '65536'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '65536'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: short
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '7355'
    psize: '1400'
    type: short
    vlen: '1'
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-25000'
    decim: '4'
    samp_rate: samp_rate
    taps: xlate_taps
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '25000'
    decim: '4'
    samp_rate: samp_rate
    taps: xlate_taps
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    int_max: '0'
    int_min: '-120'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_HAMMING
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    bw0: '192000'
    center_freq0: 162.0e6
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    dev: driver=tcpremote
    devname: custom
    overall_gain0: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: zmq_address
    timeout: '100'
    type: short
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_short_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', blocks_float_to_short_0, '0']
- [blocks_float_to_short_0, '0', blocks_interleave_0, '1']
- [blocks_float_to_short_0_0, '0', blocks_interleave_0, '0']
- [blocks_interleave_0, '0', blocks_udp_sink_0, '0']
- [blocks_interleave_0, '0', zeromq_push_sink_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [soapy_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [soapy_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
